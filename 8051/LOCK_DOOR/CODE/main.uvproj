# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S53 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./lcd/: lcd_16x2.c
    ./delay/: delay.c
    ./i2c/: i2c.c
    ./24cxx/: 24cxx.c
    ./Keypad/: Keypad.c
    ./DS1307/: DS1307.c
